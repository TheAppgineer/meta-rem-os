FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fragment.cfg"
SRC_URI += "file://fragment-blkio-throttle.cfg"
SRC_URI += "file://fragment-no-multimedia.cfg"
SRC_URI += "file://fragment-no-legacy-sound.cfg"
